options:
  parameters:
    author: zxkmm
    generate_options: qt_gui
    id: replay_tesla
    output_language: python
    title: replay tesla
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./tesla.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '433.92'
    dev_args: '""'
    gain0: '1'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
